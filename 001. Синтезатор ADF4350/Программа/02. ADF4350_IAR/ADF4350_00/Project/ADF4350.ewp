# IAR project ADF4350.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x50
  General.SCRStackSize: 32
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1280.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group header
    ../: constants.h definitions.h main.h terminal.h variables.h
  group source
    ../: main.c terminal.c
