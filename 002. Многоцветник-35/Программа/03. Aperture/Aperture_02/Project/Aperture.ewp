# IAR project Aperture.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: dlAVRcustom.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: _SYSTEM_BUILD
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: _ECLIB; _ECLIB_ECPP
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR, debug)
  as the first configuration, except:
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x50
  General.SCRStackSize: 32
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1280.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group header
    ../: constants.h definitions.h main.h terminal.h variables.h
  group source
    ../: main.c terminal.c
